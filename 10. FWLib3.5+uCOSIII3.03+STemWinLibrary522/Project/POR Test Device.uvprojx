# Keil uVision project POR Test Device.uvprojx, settings and files
target uCOS_emWin (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: POR Test Device +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\..\Libraries\CMSIS;.\..\User;.\..\Libraries\FWlib\inc;.\..\uCOS-III\uC-CPU;.\..\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;.\..\uCOS-III\uC-LIB;.\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\..\uCOS-III\uCOS-III\Source;.\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\..\User\app;.\..\STemWinLibrary522\Config;.\..\STemWinLibrary522\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../User/app/: app.c
  group BSP
    ../User/bsp/: bsp.c
    ../User/bsp/lcd/: bsp_ili9341_lcd.c
    ../User/bsp/usart/: bsp_usart1.c
    ../User/bsp/led/: bsp_led.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group STemWin_V522
    ../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../STemWinLibrary522/Lib/: STemWin522_CM3_OS_Keil.lib
    ../STemWinLibrary522/OS/: GUI_X_uCOS.c
  group os_cfg
    ../User/app/: os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC/CPU
    ../uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm cpu.h
  group uC/LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uCOS-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/Source
    ../uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/Port
    ../uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
software components: CMSIS:CORE 5.1.2
