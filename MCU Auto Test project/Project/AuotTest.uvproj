# Keil uVision project AuotTest.uvproj, settings and files
target AutoTest (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AuotTest +hex
  c flags: Optim=4
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\FWlib\inc;..\User;..\User\LCD;..\User\Usart;..\User\Test_item;..\User\SysTick;..\User\sdcard;..\User\FF13;..\User\InputCapture
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Test_item
    ../User/Test_item/: Item1_GPIO.c Item2_BEEP.c Item3_PWM.c Item4_Timer.c Item5_UART.c Item6_WDT.c Item7_PD_Mode.c Item8_InformationBlock.c Item9_Reser.c Item10_ReadProtection.c Item_mpi.c
  group User
    ../User/: main.c stm32f10x_it.c
    ../User/SysTick/: SysTick.c
    ../User/InputCapture/: Input_capture.c
  group LCD
    ../User/LCD/: Ili9341_lcd.c Xpt2046_lcd.c
  group Usart
    ../User/Usart/: Usart.c
  group StartUp
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_sdio.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_tim.c
