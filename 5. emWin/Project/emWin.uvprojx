# Keil uVision project emWin.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RF STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0xC0000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: emWin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_XL, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\FWlib\inc;..\User;..\User\usart;..\User\SysTick;..\User\led;..\User\lcd;..\STemWinLibrary532\Config;..\STemWinLibrary532\inc;..\STemWinLibrary532\OS;..\User\SPI2
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ../Libraries/CMSIS/startup/: startup_stm32f10x_xl.s
    ../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group LIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../User/: main.c stm32f10x_it.c
    ../User/usart/: bsp_usart1.c
    ../User/led/: bsp_led.c
    ../User/SysTick/: bsp_SysTick.c
    ../User/lcd/: ILI9486_LCD.c
    ../User/SPI2/: SPI2.c
  group 322
    ../STemWinLibrary532/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../STemWinLibrary532/OS/: GUI_X.c
    ../STemWinLibrary532/Lib/: STemWin532_CM3_Keil.lib
